<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00046.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="6BFA4517-B873-4FC9-A5F1-6AFD57D49D01">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E963CF7C-A807-4D2E-810D-490883514AF8">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F76F1AFA-ACD0-4D51-8B7A-B35F0B9E89A3">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CAC32629-A0C5-4029-BC47-CAE8B0E71330">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="914F7392-CF7A-498E-9A44-40EEDDBAC9C1">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="00211907-3DFC-42C8-9151-BF171B7E7C6E">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DE294307-42BF-4873-B705-2CCE8914A308">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="CFC177D9-218A-45B4-A185-B75A9474CBC2">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0BF96A88-176B-4618-9CB0-604D1FBE3198">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E00B7128-27BB-40EE-8507-3C6E30AD5F22">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F25938AD-C32B-4EBA-B1F9-0DF6118DA91C">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="58D97157-0053-4152-9F45-5EB505B5E098">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1DE257AA-D463-4788-9E01-FF22EB378AC3">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D040B9FE-710E-4E66-870D-E510F2DEAB8A">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C0A67E43-CD2A-4B5F-953F-E34444B75A40">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="FFAECFC3-8E36-4679-97A4-2232CB30556E">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4BD01BD6-C649-41A2-9039-0CA72B2AA2BD">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="20F68B53-4A63-4624-89C1-DA1F5571AC73">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E696FB84-FD7C-4C54-AA6F-4F5BCB9FC50C">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="06066B5A-6065-4A44-82B5-A5EEB90BB70C">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2AA3F196-D72E-4A80-9CD1-E7AA315E541C">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B765A47A-712E-4594-9F79-7AB3CF92FA14">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C562FD4B-1A7D-4B2C-BA29-53C2D15B75B0">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A1F2E818-21AF-4B71-8B13-EFA82022305C">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F4C30EEA-986B-40A5-8EE1-7DC4AED014B8">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1C6EEBBA-D657-4EBF-A744-33531194AAD2">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="22A5076C-0486-4FC2-8890-3638AC7DDC13">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E7C14C3B-3B15-426A-8791-7ABDA08DAF9C">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="33A8D9E2-813B-4AEA-A521-808521FF21F4">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="25DED485-68A4-48E7-9893-57BABA9A82C1">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="92B091E7-7BE9-4D4A-8BF8-92AEB005C218">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B066421E-DDFD-4947-B509-6F224DC61578">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9AE654E7-CD20-4424-B723-EAEC8E3A5A31">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A83CF507-3D2A-4DFD-B15A-CA6B4AE20F4D">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F57C9786-F3CB-4ACC-B8AD-8E34133DDE1E">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="43024216-5CB8-4D4B-8B8E-7CF7BE1C703A">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="30C35F10-92B1-4D8B-9607-AB9294228983">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DE9FE0BF-614A-42F6-8EDE-8986374402F8">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3EE69D23-A558-4AB8-BE56-507D49897CC5">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="68727181-79F6-42DF-B93B-8949BE2C8471">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="65EFC602-871D-4EA7-BB8E-91B19F8E3AD9">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F2577C83-CF42-4717-9E48-0642CEC92CDB">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BB1BACBF-E60B-4C75-A8C8-272B2C0D162C">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B8EA8F6-059D-4CF3-B6CE-6781BA9E56C1">
      <SHORT-NAME>SWC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="61FA59B0-ACD0-40F1-ACBE-B5FD26D2889A">
      <SHORT-NAME>DataType</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="52ACEB04-E88E-4FD8-9F2F-C4D7FB3DC1B9">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FFCA7D81-634A-4361-BAE4-CE2A372D8C8B">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>