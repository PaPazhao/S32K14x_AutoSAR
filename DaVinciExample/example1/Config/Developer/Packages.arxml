<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00044.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="14216122-BC82-46A8-B935-F23688FDFF37">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1477F211-867E-4691-8B23-BC03D3209E87">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C79F9653-1F24-4FD1-B7AD-88235B4F6587">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9855C9C5-67D2-4B8B-AA1F-ACC926F27031">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9045680C-4BFF-4F76-A304-CADD5E20CCF4">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="02E4539D-AE15-4CF6-AA89-F0A343217910">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F2F0BCE1-346D-4854-AD12-5F0AF6AA1100">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8C1998A5-E951-460C-8C5D-6F77FF8F5A8F">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D48777ED-E78A-4596-B8C9-2B0D3AAA2DA1">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B1588F0D-D44D-469D-B5DC-3F1AC2047F46">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="13E269AA-3536-45CB-AB57-55E654AC9A87">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2D29794D-9D84-4333-8E94-398ABAFB1638">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9E198AA6-7E6D-468E-9959-906F92920CD6">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6AE18CEB-D9E1-4339-B94D-345239D74883">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9ADA7676-26A9-47B8-875B-8DCDD6286BD9">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="DBD6E83D-F484-4A70-B87F-087733FA3BF2">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F3E819EB-2058-427A-A343-F68DFC2CC12E">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F58B7E91-3FD5-4ECF-B627-876B1C686FAE">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FB287120-ABC7-45DA-8A7C-9CE4E89C4A45">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4ABD494A-7EBC-4E84-8A4A-FE9EB2F4B6A4">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EDC07A28-0898-4295-BB84-F2838D36E3B9">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3FF8443F-850E-441F-AF6D-B8F2509D86CD">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="510F0C8E-460C-4C0F-AB5D-AF5B907F9C81">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A3726EC3-3A79-4C2A-8F0F-C7CBA6020774">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="627D798D-27B4-4EF6-949B-4C1EC4DBEFF7">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8834017B-0FB1-4DD4-93CC-24F055D4999D">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="56936D82-C279-491D-920B-CD5E9629C4DF">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A7E4551B-04E7-448E-8F60-97502CF6B06E">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C5A8CE16-BF26-4527-8915-E10655B7D4E4">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C5D528C-EF4E-468A-A4BB-48FA257A8845">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="40845DDF-A5C3-4C13-8B53-C77F070AEE0C">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4C6A55E9-EE02-4200-A622-A65A385AFB85">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4C98E88E-74B6-47E6-ACB5-ABEEA622F1E4">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6ED0EC32-DCE9-454D-9B75-B03E649640C2">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DE16F2CA-5E21-4A6B-8789-66B06D38FF49">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6BA32FB4-2661-4A3A-8394-C8AEB9AF98A3">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="31E4E0BE-89E5-4C47-9E4C-5F97EE866637">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2801BF46-DFAF-48A2-B31A-8E92842A1802">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="05A2409B-E3BF-4DA8-A397-CA6428973558">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="573202F5-D57D-4680-BF7E-E8E7EBFE3B72">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="105C9E7A-4694-46C4-8DC5-88745A15A5F6">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="46441AC8-D35A-42C8-98E8-CD0B2BED22FD">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C426055E-C9EE-42F3-BEBB-C3DF53DF4B8B">
      <SHORT-NAME>DataType</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="18F4A1EF-730C-45FE-9CBF-9968DC489101">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="27D2ED8E-8FA8-448B-91D9-4004FB7D4B40">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>